## esp32/main/Kconfig.projbuild
```kconfig
menu "App Configuration"

config TARGET_PHONE
	bool "Configure things for embedding in a gutted phone"
	default n

endmenu
```
